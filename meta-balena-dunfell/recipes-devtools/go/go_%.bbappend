require fix-go-ldso.inc
