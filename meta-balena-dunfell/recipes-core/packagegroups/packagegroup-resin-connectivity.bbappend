CONNECTIVITY_FIRMWARES_append = " \
    wireless-regdb-static \
    "
