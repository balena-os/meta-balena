IMAGE_ROOTFS_MAXSIZE = "16384"
