HOSTAPP_HOOKS += "99-resin-grub"
