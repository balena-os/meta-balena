require go-1.9-fixes.inc
