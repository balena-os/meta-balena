TARGET_REPOSITORY_nuc = "resin/amd64-supervisor"
LED_FILE_nuc = "/dev/null"
