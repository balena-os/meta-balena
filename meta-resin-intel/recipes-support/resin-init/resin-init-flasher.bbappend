# the type of bootloader the target board uses
BOARD_BOOTLOADER_nuc = "grub-efi"

# On Intel NUC, we flash on internal hard disk drive
INTERNAL_DEVICE_KERNEL_nuc = "sda"
