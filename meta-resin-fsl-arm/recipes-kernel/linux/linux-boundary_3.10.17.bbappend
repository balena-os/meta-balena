# Use custom defconfig
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"
