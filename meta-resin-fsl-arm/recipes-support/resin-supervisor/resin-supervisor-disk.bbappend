TARGET_REPOSITORY_nitrogen6x = "resin/armv7hf-supervisor"
PARTITION_SIZE_nitrogen6x = "1024"
