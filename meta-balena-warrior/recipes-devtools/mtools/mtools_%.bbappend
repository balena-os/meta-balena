SRC_URI += "file://initialize-direntry.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

