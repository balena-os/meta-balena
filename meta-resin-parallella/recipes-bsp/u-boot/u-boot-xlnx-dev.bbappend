# Avoid useless warning using a tiny hack:
# NOTE: multiple providers are available for runtime u-boot-xlnx-dev (u-boot-xlnx-dev, u-boot-xlnx)
# NOTE: consider defining a PREFERRED_PROVIDER entry to match u-boot-xlnx-dev
COMPATIBLE_MACHINE = "(-)"
