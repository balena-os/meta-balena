TARGET_REPOSITORY_parallella = "resin/armv7hf-supervisor"
PARTITION_SIZE_parallella = "1024"
LED_FILE_parallella = "/sys/class/leds/CR10/brightness"
