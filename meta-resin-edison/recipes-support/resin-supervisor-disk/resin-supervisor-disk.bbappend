TARGET_REPOSITORY_edison = "resin/i386-supervisor"
PARTITION_SIZE_edison = "1024"
LED_FILE_edison = "/dev/null"
