DEPENDS_append_class-target = " libdevmapper"
