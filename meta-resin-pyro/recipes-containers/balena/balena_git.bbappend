
do_compile_prepend() {
	export GO="${HOST_PREFIX}go"
}
