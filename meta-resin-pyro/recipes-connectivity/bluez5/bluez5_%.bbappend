SRC_URI += "file://run-bluetoothd-with-experimental-flag.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

