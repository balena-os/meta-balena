../../../meta-balena-dunfell/recipes-devtools/go/go_%.bbappend