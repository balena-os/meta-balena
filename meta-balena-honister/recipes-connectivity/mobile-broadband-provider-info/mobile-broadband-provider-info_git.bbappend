# mobile-broadband-provider-info 'master' branch was renamed to 'main' causing do_fetch() to fail
SRC_URI = "git://gitlab.gnome.org/GNOME/mobile-broadband-provider-info.git;protocol=https;branch=main"
