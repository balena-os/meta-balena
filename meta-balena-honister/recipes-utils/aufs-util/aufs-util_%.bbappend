SECURITY_CFLAGS:pn-${PN} = "${SECURITY_NOPIE_CFLAGS}"
