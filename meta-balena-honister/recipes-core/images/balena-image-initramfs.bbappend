PACKAGE_INSTALL:append = " initramfs-module-console-null-workaround"
