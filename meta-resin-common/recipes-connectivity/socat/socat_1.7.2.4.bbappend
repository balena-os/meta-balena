# Fix strange license
LICENSE = "GPL-2.0-with-OpenSSL-exception"
