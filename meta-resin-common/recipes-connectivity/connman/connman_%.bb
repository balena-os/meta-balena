RDEPENDS_${PN} = "resin-connman-conf"
