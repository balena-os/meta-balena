# Default the home directory to root's one
# Used for persistent random state file
CFLAGS_append_class-target = " -DDEFAULT_HOME=/home/root"
