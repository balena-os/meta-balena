SUMMARY = "A pipeline manipulation library"
LICENSE = "GPLv3"
LIC_FILES_CHKSUM = "file://COPYING;md5=d32239bcb673463ab874e80d47fae504"

inherit autotools pkgconfig

SRC_URI = "http://download.savannah.gnu.org/releases/libpipeline/${BP}.tar.gz"
SRC_URI[md5sum] = "e54590ec68d6c1239f67b5b44e92022c"
SRC_URI[sha256sum] = "da46d7b20163aadb9db2faae483f734e9096a7550c84b94029abeab62dd1b9ee"
