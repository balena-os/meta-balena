# Compile with new GCC 5
CFLAGS += "-fgnu89-inline"
