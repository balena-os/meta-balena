PACKAGECONFIG_remove_mx6 = " egl glesv2"
