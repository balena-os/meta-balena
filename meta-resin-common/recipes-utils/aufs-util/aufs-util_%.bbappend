PACKAGES =+ "${PN}-auplink"

FILES_${PN}-auplink = "/sbin/auplink"
