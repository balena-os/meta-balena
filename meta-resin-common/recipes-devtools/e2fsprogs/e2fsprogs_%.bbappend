PACKAGES =+ "e2fsprogs-dumpe2fs"

FILES_e2fsprogs-dumpe2fs = "${base_sbindir}/dumpe2fs*"
