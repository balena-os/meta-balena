DEPENDS_append = " virtual/${TARGET_PREFIX}gcc libgcc"
INHIBIT_SYSROOT_STRIP = "1"
