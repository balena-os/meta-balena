DEPENDS = "virtual/${TARGET_PREFIX}gcc"
