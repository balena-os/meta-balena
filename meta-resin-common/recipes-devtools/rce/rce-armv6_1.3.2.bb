require rce-armv6.inc

PR = "r2"

SRC_URI[rce.md5sum] = "cbd5826254c88d86d4144f2290abc7b1"
SRC_URI[rce.sha256sum] = "163930ea5bad27a543234e8a7d0c97d16558bf40604f1b8ffb57633b2f7f0fb8"
