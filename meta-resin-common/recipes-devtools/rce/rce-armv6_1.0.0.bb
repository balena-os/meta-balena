require rce-armv6.inc

PR = "r0"

SRC_URI[rce.md5sum] = "c92ce7fb019a0f1f6a9aefcb1595dafd"
SRC_URI[rce.sha256sum] = "f227026cc35107b92509f345e72bd229dda7f76ee2c710a04b2585ebed2ab15f"
