require rce-i386.inc

PR = "r1"

SRC_URI[rce.md5sum] = "415037c56ff6f5cd53af0d51b3fecbed"
SRC_URI[rce.sha256sum] = "edaa1a9d23f4dbd00e0de69c2a730819b64af16d1e10641c54dde4a5ff041a31"
