require rce-amd64.inc

PR = "r0"

SRC_URI[rce.md5sum] = "5a5861d53b5c85cce675c7f9faf56256"
SRC_URI[rce.sha256sum] = "0cb4eb4cd200302551ba8d8c7c106decbc276154299af0a60614f10a21ad09da"
