require rce-amd64.inc

PR = "r0"

SRC_URI[rce.md5sum] = "25268957a6c3ec430295696c33bea168"
SRC_URI[rce.sha256sum] = "0b8e3dbe28b03dc4d70f90642d6b3f1756ae2c1427985c5aff25d60e1a320804"
