require rce-armv6.inc

PR = "r3"

SRC_URI[rce.md5sum] = "8951d0e170a70db3d22033aa3bdb98f1"
SRC_URI[rce.sha256sum] = "c9e93a359ec003f83585940f71e38ae9b5a0479486ca85d84d707e23ccbd9b61"
