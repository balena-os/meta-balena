require rce-armv5.inc

PR = "r0"

SRC_URI[rce.md5sum] = "6e0a99d3ffec800213cfc92d12a97901"
SRC_URI[rce.sha256sum] = "08aa765e8a499da025db31ce2f16ce5e2a520f2e2b8cc16a5ed370c0eaf41680"
