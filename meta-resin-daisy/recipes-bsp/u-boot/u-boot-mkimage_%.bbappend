FILESEXTRAPATHS_append := ":${THISDIR}/${PN}"
SRC_URI_append = " file://gcc5.patch"
