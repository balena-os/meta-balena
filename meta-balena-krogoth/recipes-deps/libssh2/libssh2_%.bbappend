# meta-oe/recipes-support/libssh2
BBCLASSEXTEND = "native"
