# Pre morty yocto don't have this package
PACKAGES_append = " initramfs-module-rootfs"
