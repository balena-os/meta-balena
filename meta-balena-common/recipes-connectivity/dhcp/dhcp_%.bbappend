PACKAGES:append = "${PN}"
RDEPENDS:${PN} = "${PN}-client"
