FILESEXTRAPATHS_prepend := "${THISDIR}/patches:"

SRC_URI_append = " file://huawei-e3372.patch;patch=1;"
