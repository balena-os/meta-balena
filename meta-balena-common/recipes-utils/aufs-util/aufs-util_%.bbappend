PACKAGES =+ "${PN}-auplink"

FILES:${PN}-auplink = "/sbin/auplink"

#SECURITY_CFLAGS:pn-${PN} = "${SECURITY_NOPIE_CFLAGS}"
