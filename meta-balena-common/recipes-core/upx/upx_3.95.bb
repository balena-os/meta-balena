include upx.inc

SRC_URI = " \
    https://github.com/upx/upx/releases/download/v${PV}/upx-${PV}-src.tar.xz \
    "
SRC_URI[md5sum] = "fa95336d9ddcaac3b494a1b6ae9d3557"
SRC_URI[sha256sum] = "3b0f55468d285c760fcf5ea865a070b27696393002712054c69ff40d8f7f5592"
