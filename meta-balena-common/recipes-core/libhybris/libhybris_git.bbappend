DEPENDS += "wayland"
EXTRA_OECONF += "--enable-wayland"
