inherit kernel-resin
