PACKAGECONFIG:append = " zstd"
