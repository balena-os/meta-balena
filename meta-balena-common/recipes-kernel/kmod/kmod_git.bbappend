EXTRA_OECONF +=" --with-xz"
DEPENDS += "xz"
