
FILESEXTRAPATHS_append := ":${THISDIR}/${PN}"
SRC_URI_append = " file://initialize-direntry.patch"

