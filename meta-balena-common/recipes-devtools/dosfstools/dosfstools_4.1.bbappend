SRC_URI:append = " file://0001-src-check.c-Fix-up-mtools-created-bad-dir-entries.patch"
