SRCREV = "d81bc142d7068073699ce6ffbfbdf268baa9f200"

PACKAGES =+ "${PN}-iwlwifi-7265D-10"

RDEPENDS_${PN}-iwlwifi-7265D-10 = "${PN}-iwlwifi-license"

FILES_${PN}-iwlwifi-7265D-10 = "/lib/firmware/iwlwifi-7265D-10.ucode"
