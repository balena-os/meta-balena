IMAGE_INSTALL_append = " ${ROOTFS_PKGMANAGE_BOOTSTRAP}"
