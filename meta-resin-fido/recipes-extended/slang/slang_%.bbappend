EXTRA_OECONF += "--with-x=no"
