FILESEXTRAPATHS_append := ":${THISDIR}/files"
SRC_URI_append = " file://grub-Backport-const-qualifier-fix-for-gcc-5.patch"
