PACKAGES =+ "${PN}-libs"
FILES_${PN}-libs = "${libdir}/*.so.*"
