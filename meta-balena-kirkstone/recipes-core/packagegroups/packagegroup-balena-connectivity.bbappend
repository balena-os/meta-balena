CONNECTIVITY_FIRMWARES:append = " \
    linux-firmware-iwlwifi-9260 \
    linux-firmware-wl18xx \
    wireless-regdb-static \
    "
