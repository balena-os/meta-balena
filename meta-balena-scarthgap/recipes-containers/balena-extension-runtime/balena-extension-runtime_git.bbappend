S = "${WORKDIR}/${BPN}/src/${GO_IMPORT}"
