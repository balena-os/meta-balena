FILESEXTRAPATHS_append := ":${THISDIR}/${PN}"
SRC_URI_append = " file://0001-mkfs-Default-to-64-32-heads-sectors-for-targets-smal.patch"
