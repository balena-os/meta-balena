PACKAGES =+ "${PN}-iwlwifi-7265d-13"
RDEPENDS_${PN}-iwlwifi-7265d-13 = "${PN}-iwlwifi-license"
FILES_${PN}-iwlwifi-7265d-13 = "/lib/firmware/iwlwifi-7265D-13.ucode"

PACKAGES =+ "${PN}-iwlwifi-8000c-13"
RDEPENDS_${PN}-iwlwifi-8000c-13 = "${PN}-iwlwifi-license"
FILES_${PN}-iwlwifi-8000c-13 = "/lib/firmware/iwlwifi-8000C-13.ucode"
