FILESEXTRAPATHS_prepend := "${THISDIR}/config:"
SRC_URI += "file://docker.cfg \
                "
