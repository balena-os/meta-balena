include resin-image.inc

# Overlays for capemgr
IMAGE_INSTALL_beaglebone += "bb-org-overlays"
