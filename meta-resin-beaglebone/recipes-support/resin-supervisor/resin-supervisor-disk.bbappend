TARGET_REPOSITORY_beaglebone = "resin/armv7hf-supervisor"
LED_FILE_beaglebone = "/sys/class/leds/beaglebone\:green\:usr3/brightness"
