TARGET_REPOSITORY_nuc = "resin/amd64-supervisor"
PARTITION_SIZE_nuc = "1024"
LED_FILE_nuc = "/dev/null"
