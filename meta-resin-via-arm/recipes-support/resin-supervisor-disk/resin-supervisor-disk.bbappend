TARGET_REPOSITORY_vab820-quad = "resin/armv7hf-supervisor"
PARTITION_SIZE_vab820-quad = "1024"
LED_FILE_vab820-quad = "/dev/null"
