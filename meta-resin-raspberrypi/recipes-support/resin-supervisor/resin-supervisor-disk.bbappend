TARGET_REPOSITORY_raspberrypi = "resin/rpi-supervisor"
PARTITION_SIZE_raspberrypi = "1024"
