FILESEXTRAPATHS_prepend_rpi := "${THISDIR}/files:"

RDEPENDS_${PN}_append = " kmod"
