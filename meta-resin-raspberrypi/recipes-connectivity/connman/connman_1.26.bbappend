FILESEXTRAPATHS_append := "${THISDIR}/files:"
SRC_URI_append = " \
    file://unprotected_wifi_tether.patch \
    "
