CONNECTIVITY_PACKAGES_append = " crda"
