PROVIDES += "virtual/${TARGET_PREFIX}go"
