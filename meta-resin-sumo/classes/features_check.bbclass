# prior to poky dunfell 'distro_features_check' was used
# this will maintain compatibility on older branches
inherit distro_features_check
