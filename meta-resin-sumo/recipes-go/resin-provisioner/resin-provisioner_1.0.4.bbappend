do_compile() {
    export CGO_ENABLED=1
    go_do_compile
}
