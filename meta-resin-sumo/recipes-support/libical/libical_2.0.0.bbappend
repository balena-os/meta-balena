do_install_append() {
	rm -rf "${D}/usr/lib/cmake/"
}
