inherit kernel-resin

COMPATIBLE_MACHINE = "ts4900"
