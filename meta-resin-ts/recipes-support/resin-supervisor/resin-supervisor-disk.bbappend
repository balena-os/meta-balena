# ts4900
TARGET_REPOSITORY_ts4900 = "resin/armv7hf-supervisor"

# ts7700
TARGET_REPOSITORY_ts7700 = "resin/armel-supervisor"
