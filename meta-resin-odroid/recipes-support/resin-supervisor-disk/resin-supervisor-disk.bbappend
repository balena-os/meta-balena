# ODROID-UX3
TARGET_REPOSITORY_odroid-ux3 = "resin/armv7hf-supervisor"
PARTITION_SIZE_odroid-ux3 = "1024"
LED_FILE_odroid-ux3 = "/sys/class/leds/blue\:heartbeart/brightness"

# ODROID-C1
TARGET_REPOSITORY_odroid-c1 = "resin/armv7hf-supervisor"
PARTITION_SIZE_odroid-c1 = "1024"
LED_FILE_odroid-c1 = "/sys/class/leds/blue\:heartbeat/brightness"
