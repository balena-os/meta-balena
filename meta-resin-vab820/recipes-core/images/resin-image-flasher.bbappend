include resin-image.inc

# Put the resin image and initramfs inside the boot partition
RESIN_BOOT_PARTITION_FILES_append_vab820-quad = " resin-image-vab820-quad.resin-sdcard"
