CONNECTIVITY_FIRMWARES_append = " \
    linux-firmware-wl18xx \
    wireless-regdb-static \
    "
