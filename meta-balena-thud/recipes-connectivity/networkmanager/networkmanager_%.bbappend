inherit bluetooth
