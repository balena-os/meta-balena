# This yocto version provides the openssl binary in the 'openssl' package
OPENSSL_PKG = "openssl"
