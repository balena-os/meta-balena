require fix-goarch.inc
