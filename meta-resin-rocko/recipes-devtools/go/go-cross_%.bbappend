require fix-goarch.inc

PROVIDES += "virtual/${TARGET_PREFIX}go"
