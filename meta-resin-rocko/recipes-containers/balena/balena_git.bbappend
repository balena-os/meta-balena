# No support for static PIE in rocko
MOBYNIT_EXTRA_LDFLAGS_append = " -no-pie"
