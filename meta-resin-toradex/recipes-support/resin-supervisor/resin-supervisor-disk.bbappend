# Apalis imx6 
TARGET_REPOSITORY_apalis-imx6 = "resin/armv7hf-supervisor"
PARTITION_SIZE_apalis-imx6 = "1024"
# Colibri imx6 
TARGET_REPOSITORY_colibri-imx6 = "resin/armv7hf-supervisor"
PARTITION_SIZE_colibri-imx6 = "1024"
