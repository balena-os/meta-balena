INTERNAL_DEVICE_KERNEL_apalis-imx6 = "mmcblk0"
INTERNAL_DEVICE_KERNEL_colibri-imx6 = "mmcblk0"
