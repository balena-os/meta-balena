inherit gobject-introspection

FILES_libnmglib += " \
    ${libdir}/libnm-glib.so.* \
    ${libdir}/girepository-*/*.typelib \ 
    "
