# Make sure you have the sdcard resin image ready
IMAGE_DEPENDS_resin-sdcard_append = " resin-image:do_image_resin_sdcard"
