IMAGE_FSTYPES_zc702-zynq7 = "resin-sdcard"

# Customize resin-sdcard
RESIN_BOOT_PARTITION_FILES_zc702-zynq7 = " \
    boot.bin: \
    u-boot.img: \
    uEnv.txt: \
    uImage: \
    device-trees/zc702-zynq7.dtb: \
    "
