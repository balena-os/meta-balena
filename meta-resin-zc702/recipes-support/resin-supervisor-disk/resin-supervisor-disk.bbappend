TARGET_REPOSITORY_zc702-zynq7 = "resin/armv7hf-supervisor"
LED_FILE_zc702-zynq7 = "/sys/class/leds/ds23/brightness"
